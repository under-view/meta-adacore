CC:append:class-nativesdk = " -I${RECIPE_SYSROOT_NATIVE}/usr/include"
