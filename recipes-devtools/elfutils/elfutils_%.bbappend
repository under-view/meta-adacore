do_configure[depends] += "zlib:do_populate_sysroot"
